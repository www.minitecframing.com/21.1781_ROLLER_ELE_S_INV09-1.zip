# Autodesk Inventor assembly: 21.1781 ROLLER ELEMENT S
## iProperties
Created: 2007-05
Part Number: 21.1781 ROLLER ELEMENT S
Document SubType Name: Assembly
Designer: Andy Moles
Author: Andy Moles
