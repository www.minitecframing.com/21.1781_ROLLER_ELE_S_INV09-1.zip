# Autodesk Inventor assembly: SP010712-1
## iProperties
Created: 2013-01
Part Number: SP010712-1
Document SubType Name: Assembly
Designer: Administrator
Author: Administrator
