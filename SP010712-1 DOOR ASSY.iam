# Autodesk Inventor assembly: TEMP
## iProperties
Created: 2012-06
Part Number: TEMP
Document SubType Name: Assembly
Designer: Administrator
Author: Administrator
